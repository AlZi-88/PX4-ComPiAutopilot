## src/drivers/actuators/hiwonder_emm/Kconfig
```kconfig
menuconfig DRIVERS_ACTUATORS_HIWONDER_EMM
	bool "hiwonder_emm"
	default n
	---help---
		Enable support for hiwonder encoder motor module
```
